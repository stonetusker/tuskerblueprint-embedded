require sensornode-image-ci.bb
SUMMARY = "SensorNode controlled failure image"

SENSORNODE_FAILURE_MODE = "health"
