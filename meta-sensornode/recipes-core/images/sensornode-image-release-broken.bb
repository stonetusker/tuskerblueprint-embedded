require sensornode-image-release.bb
SUMMARY = "SensorNode release image with a controlled health failure for the OTA rollback demo"

SENSORNODE_FAILURE_MODE = "health"
